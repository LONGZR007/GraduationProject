# Keil uVision project BH-F103.uvprojx, settings and files
target emWin (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\app;..\..\STemWinLibrary522\Config;..\..\STemWinLibrary522\inc;..\..\ff10;..\..\ff10\option;..\..\User\os;..\..\User\bsp\usart;..\..\User\bsp\as608;..\..\User\bsp\OLED;..\..\User\bsp\cm_backtrace;..\..\User\bsp\rtc;..\..\User\bsp\ds1302
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group DOC
    ../../Doc/: readme.txt
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group BSP
    ../../User/bsp/: bsp.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/bsp/spi_flash/: fatfs_flash_spi.c
    ../../User/bsp/Key/: key.c
    ../../User/bsp/Beep/: beep.c
    ../../User/bsp/as608/: drv_as608.c
    ../../User/bsp/usart/: bsp_usart_dma.c bsp_usart1.c
    ../../User/bsp/OLED/: drv_oled.c drv_si2c.c
    ../../User/bsp/rtc/: bsp_date.c bsp_rtc.c
    ../../User/bsp/ds1302/: drv_ds1302.c
    ../../User/bsp/ov7725/: bsp_ov7725.c bsp_sccb.c
    ../../User/bsp/sdcard/: bsp_sdio_sdcard.c
    ../../User/bsp/ESP8266/: bsp_esp8266.c
  group os_cfg
    ../../User/os/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group app
    ../../User/app/: app.h app.c appicon.c Touch_CalibrationApp.c KEYapp.c app_as608.c keypadapp.c pysearch.c common.c AppSettings.c Clockapp.c Cameraapp.c AppWiFi.c
    ../../User/: includes.h
  group STemWin_V522
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_OS_Keil.lib
    ../../STemWinLibrary522/OS/: GUI_X_uCOS.c GUI_X_Touch_Analog.c
  group ff10
    ../../ff10/: diskio.c ff.c firecc936.c
  group cm_traceback
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
