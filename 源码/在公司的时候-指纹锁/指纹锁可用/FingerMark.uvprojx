# Keil uVision project FingerMark.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FingerMark
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Driver;.\App;.\BSP;..\Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group Driver
    ../Driver/src/: stm32f10x_afio.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_systick.c stm3210x_tim.c
  group BSP
    ./BSP/: drv_io.c drv_oled.c drv_remote.c drv_as608.c usart2.c drv_si2c.c
  group App
    ./App/: app_main.c app_task.c app_as608.c
